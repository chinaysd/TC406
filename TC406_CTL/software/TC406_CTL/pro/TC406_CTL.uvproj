# Keil uVision project TC406_CTL.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F7545 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0x6FF) CLOCK(16000000)
  output: TC406_CTL +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\pro;..\app;..\bsp;..\lib\inc;..\bsp\pushrod;..\bsp\message;..\bsp\sw_i2c
  group startup
    ./: STARTUP.A51
  group app
    ../app/: app.c
  group pro
    ./: main.c
  group bsp
    ../bsp/: bsp_timer.c TimeOut.c bsp_uart.c
    ../bsp/pushrod/: pushrod.c pushrod_port.c
    ../bsp/message/: msge.c msge_port.c
    ../bsp/sw_i2c/: bsp_i2c_port.c bsp_i2c_s.c
